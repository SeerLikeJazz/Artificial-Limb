# Repository SeerLikeJazz/Artificial-Limb

## EAGLE design SCH_artificial limb/art_limb.brd

Parts:
B-2: SIDE-BUTTON
C1: 106; C0402
C13, C31, C32, C33, C34, C35, C36, C37, C38: 104; C0402
C16, C28: 10uf; C0402
C29, C30: 20pf; C0402
D1: BLUE-0402; LED-0402
HDMI-1: MICRO-HDMI; HDMI
J1, J2: 4p-2.54; H4-2.54
J3, J4: 1p-2.54; 1P-65/35MIL
R1: 510R; R0402
R27, R28, R30: 10k; R0402
R29: 1M; R0402
SW3P-1: LD-CCB-001; SW3-2.54-9.0X3.5X3.5+2.0MM
U$1: STM32F40XSTM32D40X; LQFP100
U$2, U$3, U$4, U$5, U$6: TEST-POINT
W25Q128: W25Q128; SOP08
Y2: 8MHZ; X4-SMD-3.2X2.5X0.7MM

Connections:
+3V3: C1.2, C13.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, HDMI-1.18 (X18), J4.1, R1.2, R30.2, U$1.11 (VDD), U$1.19 (VDD1), U$1.21 (VREF+), U$1.22 (VDDA), U$1.28 (VDD2), U$1.50 (VDD3), U$1.75 (VDD4), U$1.100 (VDD5), W25Q128.3 (WP#), W25Q128.7 (HOLD), W25Q128.8 (VCC)
AD1: HDMI-1.1 (TX2_P), U$1.24 (PA1)
AD2: HDMI-1.3 (TX2_N), U$1.25 (PA2)
AD3: HDMI-1.5 (X5), U$1.26 (PA3)
AD4: HDMI-1.9 (TX0_N), U$1.29 (PA4)
AD5: HDMI-1.11 (X11), U$1.30 (PA5)
AD6: HDMI-1.15 (SCL), U$1.31 (PA6)
AD7: HDMI-1.17 (X17), U$1.32 (PA7)
AD8: HDMI-1.19 (HPD), U$1.35 (PB0)
BOOT1: R28.2, U$1.37 (PB2)
BUTTON: SW3P-1.2 (B), U$1.88 (PD7)
EN-A: J1.3, U$1.90 (PB4)
EN-B: J2.3, U$1.91 (PB5)
GND: B-2.P$2 (1), C1.1, C13.1, C16.2, C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, D1.-, HDMI-1.7 (SHIELD0), HDMI-1.16 (SDA), HDMI-1.P$1 (GND3), HDMI-1.P$2 (GND4), HDMI-1.P$3 (GND2), HDMI-1.P$4 (GND1), J3.1, R27.1, R28.1, SW3P-1.1 (A), U$1.10 (VSS), U$1.20 (VSSA), U$1.27 (VSS1), U$1.74 (VSS2), U$1.99 (VSS3), U$4.P$1, W25Q128.4 (GND)
IN1: J1.2, U$1.78 (PC10)
IN2: J1.4, U$1.79 (PC11)
IN3: J2.4, U$1.97 (PE0)
IN4: J2.2, U$1.98 (PE1)
MOTOR_CTRL: HDMI-1.2 (X2), U$1.63 (PC6)
unnamed: D1.+, R1.1
unnamed: C16.1, U$1.49 (VCAP_1)
unnamed: C28.1, U$1.73 (VCAP_2)
unnamed: R27.2, U$1.94 (BOOT0)
OSC_IN: C29.1, R29.2, U$1.12 (PH0), Y2.1 (2)
OSC_OUT: C30.1, R29.1, U$1.13 (PH1), Y2.3 (4)
RST: B-2.P$1 (2), C38.2, R30.1, U$1.14 (NRST)
RX1: U$1.93 (PB7), U$2.P$1
SENSE-A: J1.1, U$1.36 (PB1)
SENSE-B: J2.1, U$1.15 (PC0)
SPI2_CLK: U$1.52 (PB13), W25Q128.6 (CLK)
SPI2_CS: U$1.51 (PB12), W25Q128.1 (CS)
SPI2_MISO: U$1.53 (PB14), W25Q128.2 (SO)
SPI2_MOSI: U$1.54 (PB15), W25Q128.5 (SI)
SWD_CLK: HDMI-1.6 (TX1_N), U$1.76 (PA14), U$6.P$1
SWD_IO: HDMI-1.8 (X8), U$1.72 (PA13), U$5.P$1
TX1: U$1.92 (PB6), U$3.P$1

Notes on the sheet:
6、7、8--SWD 12、13、14--串口1

Board: 2 copper layers, 25.0 x 40.0 mm, 35 parts (0 on the bottom side), 36 nets.

## EAGLE design L298host/untitled.brd

Parts:
C1, C4: 104; C0402
C2: 10uf; C0402
C3: 10uF; C0402
C5, C6: 1uf; C0402
C7, C8, C9, C11: 100nF; C0402
C10: 4.7uF; C0402
D1: SS14; SMA
J1, J2, J5: 4p-2.54; H4-2.54
J3, J4: 1p-2.54; 1P-65/35MIL
J6: 2p-2.54; H2-2.54
P-1: L298P; POWERSO-20
R1, R2, R3, R4: 1R; R0402
R5, R6: 47R; R0402
RT9013: RT9013; SOT23-5
U1: CJT1117-5.0; SOT-223

Connections:
+3V3: C6.1, J4.1, RT9013.5 (VOUT)
+5V: C3.2, C4.2, C5.2, C7.2, P-1.12 (VSS), RT9013.1 (VIN), RT9013.3 (EN), U1.2 (OUT), U1.TER (OUT)
EN-A: J2.3, P-1.8 (EN-A)
EN-B: J1.3, P-1.14 (EN-B)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.1, J3.1, J5.4, P-1.1 (GND), P-1.10 (GND1), P-1.11 (GND2), P-1.20 (GND3), P-1.GND, R1.1, R2.1, R3.2, R4.2, RT9013.2 (GND), U1.1 (GND)
IN1: J2.2, P-1.7 (INPUT1)
IN2: J2.4, P-1.9 (INPUT2)
IN3: J1.4, P-1.13 (INPUT3)
IN4: J1.2, P-1.15 (INPUT4)
unnamed: D1.A, J5.1
unnamed: P-1.2 (SS-A), R1.2, R2.2, R5.1
unnamed: P-1.19 (SS-B), R3.1, R4.1, R6.1
OUT1: J5.3, P-1.4 (OUT1)
OUT2: J5.2, P-1.5 (OUT2)
OUT3: J6.1, P-1.16 (OUT3)
OUT4: J6.2, P-1.17 (OUT4)
SENSE-A: C11.2, J2.1, R5.2
SENSE-B: C9.2, J1.1, R6.2
VS: C1.2, C2.2, C8.2, C10.2, D1.C, P-1.6 (VS), U1.3 (IN)

Notes on the sheet:
Low-band Pass filter 34Hz

Board: 2 copper layers, 25.0 x 40.0 mm, 27 parts (0 on the bottom side), 19 nets.

## Code that names these connections

File 丹阳手多次训练/limb/limb.ioc (part):

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Mcu.Name=STM32F407V(E-G)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F407VETx
PA1.Signal=ADCx_IN1
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA4.Signal=ADCx_IN4
PA5.Signal=ADCx_IN5
PA6.Signal=ADCx_IN6
PA7.Signal=ADCx_IN7
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB12.GPIOParameters=PinState,GPIO_Label
PB12.GPIO_Label=W25Q128_CS
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=ENA
PB4.Signal=S_TIM3_CH1
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=ENB
PB5.Signal=S_TIM3_CH2
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=IN1
PC10.Signal=GPIO_Output
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=IN2
PC11.Signal=GPIO_Output
PC6.GPIOParameters=PinState,GPIO_Label
PC6.GPIO_Label=MOTOR_CTRL
PC6.PinState=GPIO_PIN_SET
PC6.Signal=GPIO_Output
PD7.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD7.GPIO_Label=BUTTON
PD7.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD7.GPIO_PuPd=GPIO_PULLUP
PD7.Signal=GPXTI7
PE0.GPIOParameters=GPIO_Label
PE0.GPIO_Label=IN3
PE0.Signal=GPIO_Output
PE1.GPIOParameters=GPIO_Label
PE1.GPIO_Label=IN4
PE1.Signal=GPIO_Output
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=limb

## Commit log

2018-01-11 完成信号识别
2018-01-27 双层叠板原理图和程序2018.01.27
2018-06-06 L298N驱动丹阳手软件更新，硬件还是上一版
